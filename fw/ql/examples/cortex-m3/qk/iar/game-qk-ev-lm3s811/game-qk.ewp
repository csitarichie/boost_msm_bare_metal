# IAR project game-qk.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3S811 Luminary LM3S811
  ICCARM.CCDefines: ewarm; PART_LM3S811
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\include; ..\..\..\..\..\ports\cortex-m3\qk\iar; $TOOLKIT_DIR$\examples\TexasInstruments\Stellaris; $TOOLKIT_DIR$\examples\TexasInstruments\Stellaris\boards\ek-lm3s811; $TOOLKIT_DIR$\examples\TexasInstruments\Stellaris\boards\ek-lm3s811\drivers
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: game-qk.bin
  ILINK.IlinkOutputFile: game-qk.out
  ILINK.IlinkIcfFile: lm3s811.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; PART_LM3S811; NDEBUG
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; PART_LM3S811; Q_SPY
  group TexasInstruments
    $EW_DIR$/arm/examples/TexasInstruments/Stellaris/driverlib/ewarm/Exe/: driverlib.a
    $EW_DIR$/arm/examples/TexasInstruments/Stellaris/boards/ek-lm3s811/drivers/: osram96x16x1.c
  group QP-Debug
    ../../../../../ports/cortex-m3/qk/iar/dbg/: libqep.a libqf.a libqk.a
  group QP-Release
    ../../../../../ports/cortex-m3/qk/iar/rel/: libqep.a libqf.a libqk.a
  group QP-Spy
    ../../../../../ports/cortex-m3/qk/iar/spy/: libqep.a libqf.a libqk.a libqs.a
  group Source
    ./: bsp.cpp main.cpp mine1.cpp mine2.cpp missile.cpp ship.cpp startup.c tunnel.cpp
